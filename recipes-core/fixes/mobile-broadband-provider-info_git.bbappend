# replaces branch=master with branch=main in the mobile-broadband-provider-info recipe file
SRC_URI = "git://gitlab.gnome.org/GNOME/mobile-broadband-provider-info.git;protocol=https;branch=main"
